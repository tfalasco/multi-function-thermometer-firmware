# IAR project Knight-bootloader_efr32.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: EFR32BG1B232F256GM56 SiliconLaboratories EFR32BG1B232F256GM56
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFR32BG1B232F256GM56; BOOTLOADER_VERSION_MAIN_CUSTOMER=(1); BTL_CONFIG_FILE="bootloader-configuration.h"; BTL_SLOT_CONFIGURATION="bootloader-slot-configuration.h"; BOOTLOADER_SECOND_STAGE; EM_MSC_RUN_FROM_FLASH; __STARTUP_CLEAR_BSS; __START=main; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\platform\bootloader\..\Device\SiliconLabs\EFR32BG1B\Include; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\platform\bootloader\..\CMSIS\Include; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\platform\bootloader; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\platform\emdrv\common\inc; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\platform\emlib\inc; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\util\third_party\mbedtls\configs; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\util\third_party\mbedtls\include; ..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1\util\third_party\mbedtls\sl_crypto\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOOTLOADER_VERSION_MAIN_CUSTOMER=(1); BTL_CONFIG_FILE="bootloader-configuration.h"; BTL_SLOT_CONFIGURATION="bootloader-slot-configuration.h"; BOOTLOADER_SECOND_STAGE; EM_MSC_RUN_FROM_FLASH; __STARTUP_CLEAR_BSS; __START=main; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Knight-bootloader.s37
  ILINK.IlinkOutputFile: Knight-bootloader.out
  ILINK.IlinkIcfFile: C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v1.1/platform/bootloader//core/IAR/main_btl_main_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EFR32BG1B232F256GM56; BOOTLOADER_VERSION_MAIN_CUSTOMER=(1); BTL_CONFIG_FILE="bootloader-configuration.h"; BTL_SLOT_CONFIGURATION="bootloader-slot-configuration.h"; BOOTLOADER_SECOND_STAGE; EM_MSC_RUN_FROM_FLASH; __STARTUP_CLEAR_BSS; __START=main; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/build/lib/: libbootloader_efr32xg1_iar.a libstorage_efr32xg1_iar.a
    ./: bootloader-callback-stubs.c bootloader-callbacks.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/core/: btl_core.c btl_main.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/core/IAR/: main_btl_startup.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/plugin/parser/: btl_image_parser.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/plugin/security/: btl_crc16.c btl_crc32.c btl_security_aes.c btl_security_ecdsa.c btl_security_sha256.c btl_security_tokens.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/plugin/security/ecc/: ecc.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/plugin/storage/: btl_storage.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/plugin/storage/internal_flash/: btl_storage_internal_flash.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_crypto.c em_emu.c em_gpio.c em_msc.c em_rmu.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/util/third_party/mbedtls/sl_crypto/src/: sl_aes.c sl_sha256.c
  group Device
    ../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v1.1/platform/bootloader/../Device/SiliconLabs/EFR32BG1B/Source/: system_efr32bg1b.c
